# Keil uVision project Lab5.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: CU_SYSC4906.LabF14_DFP.1.0.7
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: audio_in.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
